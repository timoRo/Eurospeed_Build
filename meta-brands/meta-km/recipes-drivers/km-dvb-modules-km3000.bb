KV = "3.14.2"
SRCDATE = "20140701"

require km3000-dvb-modules.inc

SRC_URI[md5sum] = "1895102873c66443b523e3c38807edf4"
SRC_URI[sha256sum] = "ee3c5b29214f17d5d264a059f8f93703fd7c088665117371d79ed2045476f979"
